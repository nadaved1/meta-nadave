SRCREV = "af09f2db0fc69fc31fac2712cc3c469e52289e8d"
SRC_URI = "git://github.com/nadaved1/hailo-u-boot.git;protocol=https;branch=1.7.0"
