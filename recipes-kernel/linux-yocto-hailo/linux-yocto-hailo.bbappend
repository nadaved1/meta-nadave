LINUX_YOCTO_HAILO_URI = "github.com/nadaved1/linux-yocto-hailo"
LINUX_YOCTO_HAILO_BRANCH = "1.7.0"
LINUX_YOCTO_HAILO_SRCREV = "5dc1af720a194356865727d8a03a094c932b7c04"
LINUX_YOCTO_HAILO_BOARD_VENDOR = "nadave"
