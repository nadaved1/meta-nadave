FILESEXTRAPATHS:prepend := "${THISDIR}/libhailort:"

SRC_URI += "file://0001-add-nadave-to-hailortcli.patch"
