IMAGE_INSTALL:append = " htop"
IMAGE_INSTALL:remove = " vim-help valgrind gstreamer1.0-plugins-bad-debugutilsbad"

IMAGE_FSTYPES:append = " squashfs"
